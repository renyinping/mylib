# Keil uVision project mylib.uvproj, settings and files
target Small (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: mylib +hex (library)
  AfterMake: mylib_copy.bat small
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group mylib
    ../src/: mem_show.c
  group uart
    ../src/uart/: uart_init.c
  group i2c
    ../src/i2c/: i2c.c i2c_byte_read.c i2c_byte_write.c i2c_dev_test.c i2c_dev_wait_offline.c i2c_dev_wait_online.c
  group i2c_mem
    ../src/i2c_mem/: i2c_mem_read_page.c i2c_mem_read.c i2c_mem_write_page.c i2c_mem_write.c i2c_mem_verify.c i2c_mem_show.c
target Large (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: as above
  output: mylib +hex (library)
  AfterMake: mylib_copy.bat large
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
